# Keil uVision project blinky_blank_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  c misc: --c99
  c include: ..\..\..
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
software components: CMSIS:CORE 4.1.0, Board Support:bsp 9.0.0, Device:Startup 8.0.3, nRF_Drivers:app_uart 3.0.1, nRF_Drivers:nrf_delay 3.0.1, nRF_Drivers:nrf_drv_common 3.0.1, nRF_Drivers:nrf_drv_gpiote 3.0.1, nRF_Drivers:nrf_drv_ppi 3.0.1, nRF_Drivers:nrf_drv_timer 3.0.1, nRF_Drivers:nrf_error 3.0.1, nRF_Drivers:nrf_gpio 3.0.1, nRF_Drivers:nrf_gpiote 3.0.1, nRF_Drivers:nrf_ppi 3.0.1, nRF_Drivers:nrf_soc 3.0.1, nRF_Drivers:nrf_timer 3.0.1, nRF_Libraries:app_error 3.0.1, nRF_Libraries:app_pwm 3.0.1, nRF_Libraries:app_timer 3.0.1, nRF_Libraries:app_util 3.0.1, nRF_Libraries:nordic_common 3.0.1, nRF_Libraries:nrf_assert 3.0.1
